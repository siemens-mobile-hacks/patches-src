-carm
-Z(CODE)PATCH_BODY,CODE,DATA_I,DATA_C,DATA_Z=A0FC2500-FFFFFFFF

-Z(CODE)PATCH_DRAWOBJECT_OBJ05=A0CAEAE4-FFFFFFFF
-Z(CODE)PATCH_DRAWOBJECT_OBJ17=A0CE8EB4-FFFFFFFF
