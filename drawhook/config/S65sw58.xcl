-carm
-Z(CODE)PATCH_BODY,CODE,DATA_I,DATA_C,DATA_Z=A0FC1F00-FFFFFFFF

-Z(CODE)PATCH_DRAWOBJECT_OBJ05=A1150EF0-FFFFFFFF
-Z(CODE)PATCH_DRAWOBJECT_OBJ17=A11758FC-FFFFFFFF
