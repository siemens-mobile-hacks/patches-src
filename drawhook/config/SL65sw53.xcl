-carm
-Z(CODE)PATCH_BODY,CODE,DATA_I,DATA_C,DATA_Z,INITTAB=A0FC1F00-FFFFFFFF

-Z(CODE)PATCH_DRAWOBJECT_OBJ05=A1148D88-FFFFFFFF
-Z(CODE)PATCH_DRAWOBJECT_OBJ17=A116A894-FFFFFFFF
