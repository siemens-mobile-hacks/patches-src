# IAR project drawhook.ewp, settings and files
configuration S65v58 (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCDefines: S65sw58
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: S65sw58
  postbuild: postbuild\postbuild.cmd $PROJ_DIR$ $EXE_DIR$ config\S65v58.txt
  XLINK.XclFile: config\S65sw58.xcl
configuration CX70v56 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CX70sw56
  AARM.ADefines: CX70sw56
  postbuild: postbuild\postbuild.cmd $PROJ_DIR$ $EXE_DIR$ config\CX70v56.txt
  XLINK.XclFile: config\CX70sw56.xcl
configuration SL65v53 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SL65sw53
  AARM.ADefines: SL65sw53
  postbuild: postbuild\postbuild.cmd $PROJ_DIR$ $EXE_DIR$ config\SL65v53.txt
  XLINK.XclFile: config\SL65sw53.xcl
configuration CX75v25 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CX75sw25
  AARM.ADefines: CX75sw25
  postbuild: postbuild\postbuild.cmd $PROJ_DIR$ $EXE_DIR$ config\CX75v25.txt
  XLINK.XclFile: config\CX75sw25.xcl
configuration SK65v50 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SK65sw50
  AARM.ADefines: SK65sw50
  postbuild: postbuild\postbuild.cmd $PROJ_DIR$ $EXE_DIR$ config\SK65v50.txt
  XLINK.XclFile: config\SK65sw50.xcl
configuration C75sw22 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: C75sw22
  AARM.ADefines: C75sw22
  postbuild: postbuild\postbuild.cmd $PROJ_DIR$ $EXE_DIR$ config\C75v22.txt
  XLINK.XclFile: config\C75sw22.xcl
  group (top)
    ./: alpha_draw.c alpha_selector.asm alpha_selector_ll.asm csm_exc.asm csm_exc.c
