# IAR project eheap.ewp, settings and files
configuration CX75sw25 (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCDefines: CX75sw25
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: CX75sw25
  XLINK.XclFile: config\CX75sw25.xcl
  group alloc
    alloc/: alloc.c alloc_sie.asm calloc.c free.c init_mem.c malloc.c realloc.c stat.c
  group config
    bcfg/: conf_loader.c config_data.c
  group devsetup
    devsetup/: ds_mopi.c ds_patch.asm
  group eheap
    eheap/: cutheap.c defapps.asm eh_lib.asm eheap.asm remap.c
  group jheap
    jheap/: jheap.c jhook.asm
